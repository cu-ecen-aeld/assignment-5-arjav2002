## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	select BR2_PACKAGE_LINUX_KERNEL
	help
	  Linux Driver Development Module 
```
